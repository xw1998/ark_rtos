# Keil uVision project ARKRTOS_TEST.uvprojx, settings and files
target ARKRTOS_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ARKRTOS_TEST +hex
  BeforeMake: py -3 ..\..\..\..\..\tools\gen_scatter.py --target kernel --output ..\..\..\..\..\build\kernel.sct
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARKRTOS_BOARD_CONFIG=\"arkrtos_board_config.h\"
  c misc: -DMDK_TRACE_SWD_EXTERNAL_PLATFORM -DMDK_TRACE_USE_CONFIG_FILE -DLFS_NO_MALLOC -DLFS_NO_ASSERT -DLFS_NO_DEBUG -DLFS_NO_WARN -DLFS_NO_ERROR -DARK_BUS_MAX_TOPICS=12 -DARK_BUS_MAX_DEVICES=4 -DARK_BUS_MSG_MAX_SIZE=128 -DARK_BUS_TOPIC_NAME_MAX=24 -DARK_BUS_QOS_MAX_SESSIONS=2 -DARK_BUS_RPC_MAX_SLOTS=4 -DARK_BUS_RPC_MAX_METHODS=4 -DARK_BUS_TASK_ENABLED=0 -DARK_BUS_COLL_ENABLED=0 -DARK_BUS_INFER_ENABLED=0 -DARK_BUS_STREAM_TX_SLOTS=1 -DARK_BUS_STREAM_RX_SLOTS=1 -DARK_BUS_STREAM_RX_MAX=256 -DARK_BUS_STREAM_MAX_BYTES=256 -DARK_BUS_CRYPTO_ENABLED=0 -DARK_BUS_ENCRYPT_ENABLED=0 -DARK_BUS_REPLAY_ENABLED=0
  c include: ../../../../../kernelsrc/components/mdk_trace;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../../../kernelsrc/include;../../../../../kernelsrc/fs;../../../../../kernelsrc/fs/littlefs;../../../../../board/stm32f427;../../../../../config;../../../../../kernelsrc/shell;../../../../../kernelsrc/shell/ark_shell;../../../../../kernelsrc/components/ark_vfs/include;../../../../../kernelsrc/components/ark_vfs/src;../../../../../kernelsrc/components/ark_vfs/port;../../../../../kernelsrc/components/lwip/src/include;../../../../../kernelsrc/components/lwip/port;../../../../../kernelsrc/components/ark_softbus/include;../../../../../kernelsrc/components/ark_softbus/src;../../../../../kernelsrc/components/ark_softbus/port
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\..\build\kernel.sct
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: system_stm32f4xx.c main.c arkrtos_isr_case.c gpio.c rtc.c sdio.c spi.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group ARKRTOS/VFS
    ../../../../../kernelsrc/src/: arkrtos_vfs.c arkrtos_vfs_lfs.c
    ../../../../../kernelsrc/components/ark_vfs/src/: ark_vfs_core.c ark_vfs_ramfs.c
    ../../../../../kernelsrc/components/ark_vfs/port/: ark_vfs_port_arkrtos.c ark_vfs_devfs.c ark_vfs_procfs.c
  group ARKRTOS/lwIP
    ../../../../../kernelsrc/components/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c sockets.c tcpip.c
    ../../../../../kernelsrc/components/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../kernelsrc/components/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../kernelsrc/components/lwip/src/netif/: ethernet.c
  group ARKRTOS/lwIP Port
    ../../../../../kernelsrc/components/lwip/port/: lwip_port.c sys_arch.c
  group ARKRTOS/Kernel
    ../../../../../kernelsrc/src/: arkrtos_task.c arkrtos_blk.c arkrtos_fs.c arkrtos_audit.c arkrtos_audit_log.c arkrtos_guard.c arkrtos_crash.c arkrtos_sign.c arkrtos_ed25519.c arkrtos_sec.c arkrtos_trace.c arkrtos_dev.c arkrtos_event.c arkrtos_eset.c arkrtos_waitmulti.c arkrtos_smp.c arkrtos_fifo.c arkrtos_cfg.c arkrtos_sync.c arkrtos_sbuf.c arkrtos_mq.c arkrtos_mempool.c arkrtos_net.c arkrtos_timer.c arkrtos_tickless.c arkrtos_rt.c arkrtos_fault.c arkrtos_hwsafe.c arkrtos_init.c arkrtos_mpu.c arkrtos_ptable.c arkrtos_layout.c arkrtos_loader.c arkrtos_mini.c arkrtos_installer.c arkrtos_log.c arkrtos_utest.c arkrtos_utest_cases.c
    ../../../../../kernelsrc/fs/littlefs/: lfs.c lfs_util.c
    ../../../../../kernelsrc/components/mdk_trace/: mdk_trace.c mdk_trace_swd.c mdk_trace_arkrtos.c
  group ARKRTOS/Softbus
    ../../../../../kernelsrc/src/: arkrtos_softbus.c
    ../../../../../board/stm32f427/: arkrtos_bus_port.c
    ../../../../../kernelsrc/components/ark_softbus/src/: ark_bus_util.c ark_bus_hal.c ark_bus_frame.c ark_bus_core.c ark_bus_discovery.c ark_bus_qos.c ark_bus_rpc.c ark_bus_caps.c ark_bus_task.c ark_bus_stream.c ark_bus_coll.c ark_bus_infer.c ark_bus_infer_ref.c ark_bus_chacha20.c ark_bus_checkpoint.c ark_bus_compress.c ark_bus_crypto.c ark_bus_flow.c ark_bus_fwu.c ark_bus_hkdf.c ark_bus_infer_kv.c ark_bus_infer_quant.c ark_bus_infer_remote.c ark_bus_infer_sampling.c ark_bus_raft.c ark_bus_replay.c ark_bus_route.c ark_bus_session.c ark_bus_subreg.c ark_bus_tokenizer.c ark_bus_tool.c ark_bus_x25519.c
    ../../../../../kernelsrc/components/ark_softbus/src/transport/: transport_loopback.c transport_uart.c
    ../../../../../kernelsrc/components/ark_softbus/port/: ark_bus_hal_arkrtos.c
  group ARKRTOS/Shell
    ../../../../../kernelsrc/shell/: platform_arkrtos.c arkrtos_shell.c arkrtos_shell_image.c arkrtos_shell_diag.c arkrtos_shell_cfg.c arkrtos_shell_fs.c arkrtos_shell_misc.c arkrtos_shell_mod.c arkrtos_shell_pmap.c arkrtos_shell_ushell.c
    ../../../../../kernelsrc/shell/ark_shell/: ark_shell.c ark_shell_commands.c ark_shell_eval.c ark_shell_history.c ark_shell_line_editor.c ark_shell_autocomplete.c
  group ARKRTOS/Board
    ../../../../../board/stm32f427/: arkrtos_board.c arkrtos_dt.c drvuart.c drvled.c drvflash.c drvwdg.c drvnor.c drvblk.c
    ../../../../../kernelsrc/port/arm/cortex-m4/: arkrtos_context.S arkrtos_port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
software components: CMSIS:CORE 4.3.0
