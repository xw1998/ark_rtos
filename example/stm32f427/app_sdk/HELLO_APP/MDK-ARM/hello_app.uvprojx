# Keil uVision project hello_app.uvprojx, settings and files
target HELLO_APP (6202200::V6.22::.\ARMCLANG)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: hello_app +hex
  BeforeMake: py -3 ..\..\..\..\..\tools\gen_app_sct.py --project hello_app.uvprojx --type app --dev-slot 1 --ram-size 8192
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -std=c99
  c include: ..\Src;..\..\..\..\..\kernelsrc\sdk\app_sdk;..\..\..\..\..\kernelsrc\include
  scatter file: ..\..\..\..\..\build\hello_app.sct
  group Hello
    ../Src/: hello_app.c
  group App_SDK
    ../../../../../kernelsrc/sdk/app_sdk/: arkrtos_app_main.c arkrtos_stdio.c arkrtos_oslib.c arkrtos_app_start.s
