# Keil uVision project mini_handover.uvprojx, settings and files
target MINI_HANDOVER (6202200::V6.22::.\ARMCLANG)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: mini_handover +hex
  BeforeMake: py -3 ..\..\..\..\..\tools\gen_app_sct.py --project mini_handover.uvprojx --type miniapp --dev-slot 1 --ram-size 8192
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -std=c99
  c include: ..\Src;..\..\..\..\..\kernelsrc\sdk\mini_sdk;..\..\..\..\..\kernelsrc\sdk\app_sdk;..\..\..\..\..\kernelsrc\include
  scatter file: ..\..\..\..\..\build\mini_handover.sct
  group Mini
    ../Src/: mini_handover.c
  group Mini_SDK
    ../../../../../kernelsrc/sdk/mini_sdk/: arkrtos_mini_main.c arkrtos_mini_start.s
    ../../../../../kernelsrc/sdk/app_sdk/: arkrtos_stdio.c arkrtos_oslib.c
