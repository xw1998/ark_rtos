# Keil uVision project socket_demo.uvprojx, settings and files
target SOCKET_DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: socket_demo +hex
  BeforeMake: py -3 ..\..\..\..\..\tools\gen_app_sct.py --project socket_demo.uvprojx --type app --dev-slot 3 --ram-size 16384 --heap-size 2048
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Src;..\..\..\..\..\kernelsrc\sdk\app_sdk;..\..\..\..\..\kernelsrc\include;..\..\..\..\..\kernelsrc\sdk\posix
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\..\build\socket_demo.sct
  group App
    ../Src/: main.c
  group App_SDK
    ../../../../../kernelsrc/sdk/app_sdk/: arkrtos_oslib.c arkrtos_app_start.s
    ../../../../../kernelsrc/sdk/posix/: arkrtos_posix.c arkrtos_libc_glue.c
