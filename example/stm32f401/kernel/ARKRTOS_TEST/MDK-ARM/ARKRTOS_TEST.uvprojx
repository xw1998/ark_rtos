# Keil uVision project ARKRTOS_TEST.uvprojx, settings and files
target ARKRTOS_TEST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ARKRTOS_TEST +hex
  BeforeMake: py -3 ..\..\..\..\..\tools\gen_scatter.py --target kernel --header config/stm32f401/arkrtos_partition.h --output ..\..\..\..\..\build\f401_kernel.sct
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xx,ARKRTOS_BOARD_CONFIG=\"arkrtos_board_config.h\"
  c misc: -DMDK_TRACE_SWD_EXTERNAL_PLATFORM -DMDK_TRACE_USE_CONFIG_FILE -DLFS_NO_MALLOC -DLFS_NO_ASSERT -DLFS_NO_DEBUG -DLFS_NO_WARN -DLFS_NO_ERROR -DARKRTOS_LOG_RING_SIZE=512 -DARKRTOS_SHELL_REDIRECT=0 -DARKRTOS_SHELL_GLOB=0 -DARK_RAMFS_MAX_DIRS=4 -DARK_SHELL_ENABLE_AUTOCOMPLETE=0 -DARKRTOS_USE_UTEST=0 -DARKRTOS_USE_PROCFS=0
  c include: ../../../../../kernelsrc/components/mdk_trace;../Core/Inc;../../../../stm32f427/kernel/ARKRTOS_TEST/Drivers/STM32F4xx_HAL_Driver/Inc;../../../../stm32f427/kernel/ARKRTOS_TEST/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../stm32f427/kernel/ARKRTOS_TEST/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../stm32f427/kernel/ARKRTOS_TEST/Drivers/CMSIS/Include;../../../../../kernelsrc/include;../../../../../kernelsrc/fs;../../../../../kernelsrc/fs/littlefs;../../../../../board/stm32f401;../../../../../config/stm32f401;../../../../../kernelsrc/shell;../../../../../kernelsrc/shell/ark_shell;../../../../../kernelsrc/components/ark_vfs/include;../../../../../kernelsrc/components/ark_vfs/src;../../../../../kernelsrc/components/ark_vfs/port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ..\..\..\..\..\build\f401_kernel.sct
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: system_stm32f4xx.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group ARKRTOS/VFS
    ../../../../../kernelsrc/src/: arkrtos_vfs.c arkrtos_vfs_lfs.c
    ../../../../../kernelsrc/components/ark_vfs/src/: ark_vfs_core.c ark_vfs_ramfs.c
    ../../../../../kernelsrc/components/ark_vfs/port/: ark_vfs_port_arkrtos.c ark_vfs_devfs.c ark_vfs_procfs.c
  group ARKRTOS/Kernel
    ../../../../../kernelsrc/src/: arkrtos_task.c arkrtos_blk.c arkrtos_fs.c arkrtos_audit.c arkrtos_guard.c arkrtos_crash.c arkrtos_sign.c arkrtos_ed25519.c arkrtos_trace.c arkrtos_dev.c arkrtos_event.c arkrtos_eset.c arkrtos_waitmulti.c arkrtos_smp.c arkrtos_fifo.c arkrtos_cfg.c arkrtos_sync.c arkrtos_sbuf.c arkrtos_mq.c arkrtos_mempool.c arkrtos_net.c arkrtos_timer.c arkrtos_tickless.c arkrtos_fault.c arkrtos_init.c arkrtos_mpu.c arkrtos_ptable.c arkrtos_layout.c arkrtos_loader.c arkrtos_swap_rollback.c arkrtos_mini.c arkrtos_installer.c arkrtos_log.c arkrtos_utest.c arkrtos_utest_cases.c
    ../../../../../kernelsrc/fs/littlefs/: lfs.c lfs_util.c
    ../../../../../kernelsrc/components/mdk_trace/: mdk_trace.c mdk_trace_swd.c mdk_trace_arkrtos.c
  group ARKRTOS/Shell
    ../../../../../kernelsrc/shell/: platform_arkrtos.c arkrtos_shell.c arkrtos_shell_image.c arkrtos_shell_diag.c arkrtos_shell_cfg.c arkrtos_shell_fs.c arkrtos_shell_misc.c arkrtos_shell_mod.c arkrtos_shell_pmap.c arkrtos_shell_ushell.c
    ../../../../../kernelsrc/shell/ark_shell/: ark_shell.c ark_shell_commands.c ark_shell_eval.c ark_shell_history.c ark_shell_line_editor.c ark_shell_autocomplete.c
  group ARKRTOS/Board
    ../../../../../board/stm32f401/: arkrtos_board.c arkrtos_dt.c drvuart.c drvled.c drvflash.c drvwdg.c
    ../../../../../kernelsrc/port/arm/cortex-m4/: arkrtos_context.S arkrtos_port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../stm32f427/kernel/ARKRTOS_TEST/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
